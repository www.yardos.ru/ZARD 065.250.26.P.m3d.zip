# KOMPAS-3D part (ZARD 065.250.26.P.m3d)

Model tree:
1. Операция без истории:1
